# Keil uVision project 003_OS_With_FIFO.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab2_BuildingSimpleOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c OS.c OS.h OS_asm.s Task.c Task.h Task_User_Config.h Semaphore.c Semaphore.h FIFO.c FIFO.h
    ../00-shared/inc/: CortexM.h
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.1
